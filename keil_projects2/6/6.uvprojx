# Keil uVision project 6.uvprojx, settings and files
target 6 (6160000::V6.16::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 6
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F103xB,USE_FULL_LL_DRIVER
  c include: .\STM32F1xx_HAL_Driver\Inc;.\STM32F1xx\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group src
    ./: main.c
  group device
    ./STM32F1xx/Source/Templates/: system_stm32f1xx.c
    ./STM32F1xx/Source/Templates/arm/: startup_stm32f103xb.s
  group LL_driver
    ./STM32F1xx_HAL_Driver/Src/: stm32f1xx_ll_utils.c stm32f1xx_ll_rcc.c
software components: CMSIS:CORE 5.5.0, Compiler:I/O:STDOUT 1.2.0
